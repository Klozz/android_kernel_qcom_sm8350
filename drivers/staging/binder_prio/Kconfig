## drivers/staging/binder_prio/Kconfig
```kconfig
config BINDER_PRIO
	tristate "Xiaomi binder prio"
	default m

if BINDER_PRIO

config BINDER_PRIO_DEBUG
	bool "Debug"

endif
```
